# Keil uVision project KZQ_V3_5.uvprojx, settings and files
target KZQ_V3_5 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KZQ_V3_5 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CORE;..\HARDWARE\CONTR;..\HARDWARE\REMOTE;..\HARDWARE\STMFLASH;..\HARDWARE\UART_485;..\HARDWARE\WDG;..\SOFTWARE\AS62;..\SOFTWARE\CMD;..\SOFTWARE\CRC;..\STM32LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\SYSTEM
  memory RVCT4: ROM 0x8002800 size 0xd800
  memory RVCT9: RAM 0x20000400 size 0x4c00
  group USER
    ../USER/: main.c stm32f10x_it.c system_init.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group STM32LIB
    ../STM32LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/: config.c
  group HARDWARE
    ../HARDWARE/CONTR/: control.c
    ../HARDWARE/REMOTE/: receive.c remote.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/UART_485/: uart_485.c
    ../HARDWARE/WDG/: wdg.c
  group SOFTWARE
    ../SOFTWARE/AS62/: drv_AS62.c
    ../SOFTWARE/CMD/: cmd.c cmd1.c
    ../SOFTWARE/CRC/: crc8_16.c
  group README
    ../: ReadMe.txt
